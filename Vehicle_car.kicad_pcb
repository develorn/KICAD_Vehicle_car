# Repository develorn/KICAD_Vehicle_car

## KiCad design Vehicle_car.kicad_pcb

Parts:
C1, C2: 10uF
C3, C4, C5, C6, C7, C10, C11, C12, C13, C14: 100nF
C8, C9: 20pF
D1: RED
DR1: DRILL_6MM_3MM
P1: SWD
P2: GPS
P3: SUPPLY
P4: COLOR_1
P5: COLOR_2
P6: MOTOR 1
P7: MOTOR 2
P8: BLUETOOTH
P9, P11: GND
P10: Length_sen
R1: 660R
R7: 100K
R8: 510R
SW1: SW_PUSH_4PIN
U1: LD1117DT33
U2: TB6612; MODULE
U3: STM32F100RB; LQFP64
X1: 8M

Connections:
+3.3V: C2.1, C3.1, C4.1, C6.1, C10.1, C11.1, C12.1, C13.1, P1.1, P2.3, P4.1, P4.5, P5.1, P5.5, P8.1, P10.3, R1.1, R7.2, U1.2 (Vout), U2.19 (STBY), U2.20 (VCC), U3.1 (VBAT), U3.13 (VDDA), U3.19 (VDD), U3.32 (VDD), U3.48 (VDD), U3.64 (VDD)
+9V: C1.1, C5.1, C14.1, P3.2 (PM), U1.3 (Vin), U2.13 (VM2), U2.14 (VM3), U2.24 (VM1)
AIN1: U2.21 (AIN1), U3.39 (PC8)
AIN2: U2.22 (AIN2), U3.40 (PC9)
AO1: P6.1, U2.1 (AO1), U2.2 (AO1)
AO2: P6.2 (PM), U2.5 (AO2), U2.6 (AO2)
BIN1: U2.17 (BIN1), U3.51 (PC10)
BIN2: U2.16 (BIN2), U3.52 (PC11)
BLUETOOTH_RX: P8.5, U3.42 (USART1_TX/TIM1_CH2/TIM15_BKIN/PA9)
BLUETOOTH_TX: P8.4, U3.43 (USART1_RX/TIM1_CH3/TIM17_BKIN/PA10)
BO1: P7.1, U2.11 (BO1), U2.12 (BO1)
BO2: P7.2 (PM), U2.7 (BO2), U2.8 (BO2)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.1, C10.2, C11.2, C12.2, C13.2, C14.2, D1.2 (K), P1.3, P2.1, P3.1, P4.2, P4.6, P5.2, P5.6, P8.2, P9.1, P10.4, P11.1, R8.1, SW1.3, SW1.4, U1.1 (GND), U2.3 (PGND1), U2.4 (PGND1), U2.9 (PGND2), U2.10 (PGND2), U2.18 (GND), U3.12 (VSSA), U3.18 (VSS), U3.31 (VSS), U3.47 (VSS), U3.63 (VSS)
GPS_RX: P2.2, U3.17 (USART2_RX/ADC1_IN3/TIM2_CH4/TIM15_CH2/P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)
GPS_TX: P2.4, U3.16 (USART2_TX/ADC1_IN2/TIM2_CH3/TIM15_CH1/P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)
LEDa: P4.8, U3.24 (PC4/ADC1_IN14)
LEDb: P5.8, U3.38 (PC7)
unnamed: R8.2, U3.60 (BOOT0)
unnamed: D1.1 (A), R1.2
NRST: C7.1, P1.5, R7.1, SW1.1, SW1.2, U3.7 (~NRST)
OSC_IN: C9.2, U3.5 (OSC_IN), X1.1
OSC_OUT: C8.2, U3.6 (OSC_OUT), X1.2
OUTa: P4.7, U3.8 (PC0/ADC1_IN10)
OUTb: P5.7, U3.9 (PC1/ADC1_IN11)
PWMA: U2.23 (PWMA), U3.26 (ADC1_IN8/TIM3_CH3/PB0)
PWMB: U2.15 (PWMB), U3.27 (ADC1_IN9/TIM3_CH4/PB1)
S0a: P4.3, U3.10 (PC2/ADC1_IN12)
S0b: P5.3, U3.25 (PC5/ADC1_IN15)
S1a: P4.4, U3.11 (PC3/ADC1_IN13)
S1b: P5.4, U3.37 (PC6)
SEN_EN: P10.1, U3.58 (I2C1_SCL/TIM4_CH1/TIM16_CH1N/PB6)
SEN_OUT: P10.2, U3.57 (I2C1_SMBA/TIM16_BKIN/PB5)
SWDCLK: P1.2, U3.49 (JTCK/SWCLK/PA14)
SWDIO: P1.4, U3.46 (JTMS/SWDIO/PA13)
SWDO: P1.6, U3.55 (JTDO/PB3)

Notes on the sheet:
OSCILATOR
RESET
Not fitted
SUPPLY
STM32F00
CONNECTORS
VM_TB
VCC_TB
VCC_uP
H_BRDGE
DRILL

Board: 2 copper layers, 75.0 x 51.0 mm, 35 parts (0 on the bottom side), 35 nets.

## Commit log

2014-10-23 Started
2014-10-23 Schematic continue
2014-10-24 GPS, Bluetooth, SWD on schematic
2014-10-31 Color sensor and TB6612 create
2014-10-31 Bluetooth, connect to STM
2014-11-04 footprint and finish schematic
2014-11-08 Finished schematic. Not checked yet
2014-11-08 PCB dimension
2014-11-18 finished PCB arrangement elements
2014-11-24 Started connect pads
2014-12-04 Finish PCB
2014-12-09 generate gerber
